## configs/a51_defconfig
```kconfig
CONFIG_CROSS_COMPILE="aarch64-linux-gnu-"
CONFIG_EXYNOS_9610=y
CONFIG_SAMSUNG_A51=y
```
